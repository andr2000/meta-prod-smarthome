#
# This class is used for optional components or those
# which are not mission critical.
#

OPT_COMP_INSTALL_DIR="/opt"

prefix="${OPT_COMP_INSTALL_DIR}"
exec_prefix="${OPT_COMP_INSTALL_DIR}"