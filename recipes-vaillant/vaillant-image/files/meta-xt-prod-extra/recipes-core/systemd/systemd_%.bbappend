PACKAGECONFIG_append = " coredump"
