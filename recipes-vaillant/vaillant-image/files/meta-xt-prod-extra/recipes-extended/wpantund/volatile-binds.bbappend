VOLATILE_BINDS += "\
    ${SMARTHOME_RPI_MNT_PERSIST}${sysconfdir}/default/wpantund ${sysconfdir}/default/wpantund\n\
"
