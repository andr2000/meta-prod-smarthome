VOLATILE_BINDS += "\
    ${SMARTHOME_RPI_MNT_PERSIST}${sysconfdir}/default/ebusd ${sysconfdir}/default/ebusd\n\
"
