VOLATILE_BINDS += "\
    ${SMARTHOME_RPI_MNT_PERSIST}${sysconfdir}/ufh-controller/ufh-controller.conf ${sysconfdir}/ufh-controller/ufh-controller.conf\n\
"
