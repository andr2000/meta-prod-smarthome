VOLATILE_BINDS += "\
    ${SMARTHOME_RPI_MNT_PERSIST}/${sysconfdir}/mosquitto/mosquitto.conf /${sysconfdir}/mosquitto/mosquitto.conf\n\
"
