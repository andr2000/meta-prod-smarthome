SUMMARY = "jsonpickle converts complex Python objects to and from JSON"
HOMEPAGE = "https://github.com/jsonpickle/jsonpickle"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://COPYING;md5=52d8d5db253a7bdc82fa3bf64e15a21e"

inherit pypi setuptools3

SRC_URI[md5sum] = "06d326f77a45c4bcdf687c38d6d03500"
SRC_URI[sha256sum] = "d3e922d781b1d0096df2dad89a2e1f47177d7969b596aea806a9d91b4626b29b"
