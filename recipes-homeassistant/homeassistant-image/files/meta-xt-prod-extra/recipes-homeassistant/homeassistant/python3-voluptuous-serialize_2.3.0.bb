SUMMARY = "Convert Voluptuous schemas to dictionaries so they can be serialized."
HOMEPAGE = "http://github.com/balloob/voluptuous-serialize"
LICENSE = "Apache-2.0"
# FIXME: Github project has LICENSE file, but not the archive from
# https://pypi.org/project/voluptuous-serialize/
LIC_FILES_CHKSUM = "file://setup.py;md5=9d00d8c1624d7316b6ad51cdbc4e7d1a"

inherit pypi setuptools3

SRC_URI[md5sum] = "29c8ab601e134ec0d3367dba6395d357"
SRC_URI[sha256sum] = "740cd00ce2ecf0f3345d550163fdd2f20de2e0a60c3c678450e68314c2f592f5"

