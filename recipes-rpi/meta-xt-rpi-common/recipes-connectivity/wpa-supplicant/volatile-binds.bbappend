VOLATILE_BINDS += "\
    ${SMARTHOME_RPI_MNT_PERSIST}/${sysconfdir}/wpa_supplicant.conf /${sysconfdir}/wpa_supplicant.conf\n\
"
