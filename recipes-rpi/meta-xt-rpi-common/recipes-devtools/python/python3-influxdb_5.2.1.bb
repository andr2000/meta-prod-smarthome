inherit setuptools3
require python-influxdb.inc

SRC_URI[md5sum] = "9263be102252c4befd1cc6e85f2bdcd4"
SRC_URI[sha256sum] = "75d96de25d0d4e9e66e155f64dc9dc2a48de74ac4e77e3a46ad881fba772e3b6"
