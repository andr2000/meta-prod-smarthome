VOLATILE_BINDS += "\
    ${SMARTHOME_RPI_MNT_PERSIST}/home/root/.ssh /${sysconfdir}/home/root/.ssh\n\
"
